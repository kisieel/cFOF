# Keil uVision project cFOF.uvprojx, settings and files
target cFOF (ARM-ADS)
  device: STM32L151C8 STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2800) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: cFOF +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32L1XX_MD
  c include: .\dev;.\inc;.\src
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group dev
    ./dev/: startup_stm32l1xx_md.s stm32l1xx.h system_stm32l1xx.c system_stm32l1xx.h
  group src
    ./src/: BUZZER.c EEPROM.c FLOAT.c KEY.c LED.c MENU.c RFM69W.c SYS_TICK.c USART.c main.c
  group inc
    ./inc/: BUZZER.h EEPROM.h FLOAT.h KEY.h LED.h main.h MENU.h RFM69W.h SYS_TICK.h USART.h
